# Keil uVision project legacy.uvprojx, settings and files
target Legacy STM32 fixture ()
  device: STM32F103C8T6 STMicroelectronics
